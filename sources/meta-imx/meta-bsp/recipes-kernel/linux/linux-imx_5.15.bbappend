FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-IMX6UL-C01-Board.patch;md5=09cae16f4b1694be967d3ca8a98200b1"
