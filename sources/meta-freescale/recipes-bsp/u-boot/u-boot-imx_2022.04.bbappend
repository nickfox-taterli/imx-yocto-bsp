FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-IMX6UL-C01-Board.patch;md5=380b843f58db6cc47d6c215c5816737b"
