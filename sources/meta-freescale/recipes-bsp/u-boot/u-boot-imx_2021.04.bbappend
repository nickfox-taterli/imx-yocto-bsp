FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-IMX6UL-C01-Board.patch;md5=ba5ad5fa378001f0e3a7898a4557591b"
